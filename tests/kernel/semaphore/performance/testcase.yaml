## tests/kernel/semaphore/performance/testcase.yaml
```yaml
tests:
  kernel.semaphore.performance:
    tags:
      - kernel
      - userspace
      - smp
```
